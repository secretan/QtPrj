# Keil uVision project JLUsb.uvproj, settings and files
target JLUsb (MCS-51)
  device: EZ-USB FX2 (CY7C68XXX) Cypress
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) XRAM(0xE000-0xE1FF) CLOCK(48000000) MODDP2
  output: JLUsb +hex
  AfterMake: ../tools/Hex2bix.exe -i -f 0xC2 -o ../JLUsb.iic Objects/JLUsb.hex
  c flags: Optimize=8 SizeSpeed=1
  group src
    ../src/: bulkloop.c fw.c FX2LPSerial.c
  group lib
    ../lib/: dscr.a51 EZUSB.LIB USBJmpTb.OBJ
